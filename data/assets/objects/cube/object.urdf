Commit message: added stuff

File: data/assets/objects/cube/object.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link baseLink: mass 0.2 -> 0.05
